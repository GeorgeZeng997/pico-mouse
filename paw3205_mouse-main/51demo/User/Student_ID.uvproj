# Keil uVision project Student_ID.uvproj, settings and files
target Student_ID (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Student_ID +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Dev;..\Sys;..\User
  group Dev
    ../Dev/: key.c led.c oled.c uart.c paw3205.c
  group Sys
    ../Sys/: timer.c delay.c
  group User
    ./: main.c
